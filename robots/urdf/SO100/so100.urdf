Commit message: Update so100.urdf

File: robots/urdf/SO100/so100.urdf (robot description, URDF)
Before this commit: robot so_arm100, 8 links, 7 joints
Links:
- link Fixed_Jaw_tip: mass None -> 0.001
